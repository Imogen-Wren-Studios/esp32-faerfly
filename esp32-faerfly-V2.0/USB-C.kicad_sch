File: esp32-faerfly-V2.0/USB-C.kicad_sch (KiCad schematic)
At the start: 8 parts

Commit message: update to new version
Parts:
- gave numbers to parts that had none: 8
